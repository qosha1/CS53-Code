# Keil uVision project WorkoutGenie.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F373RB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WorkoutGenie
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Main
    ./Main/: main.c
  group Peripherals
    ./Peripherals/: Cap_buttons.c Display.c i2c_control.c Queue.c
    ./: mpu_control.c bt_control.c HCIAPI.h HCITypes.h uart_control.c timer.c buttons.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.0
